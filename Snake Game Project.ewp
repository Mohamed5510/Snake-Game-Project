# IAR project Snake Game Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    headers/: common_macros.h std_types.h tm4c123gh6pm.h
    main/: cstartup_M.c main.c
    game/: game.c game.h
    interrupts/: interrupts.c
    os/: os.c os.h queue.c queue.h tasks.c tasks.h
    drivers/: systick.c systick.h uart.c uart.h
